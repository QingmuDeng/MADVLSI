** sch_path: inverter_tutorial/buffer.sch
**.subckt buffer A VP VN Y
*.ipin A
*.iopin VP
*.iopin VN
*.opin Y
X1 A net1 VP VN inverter
X2 net1 Y VP VN inverter
**.ends
.end
