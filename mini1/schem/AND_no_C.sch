** sch_path: mini1/schem/AND_no_C.sch
**.subckt AND_no_C
X1 net1 VN VP A B NAND2
X2 net1 Y VP VN inverter
**.ends
.end
